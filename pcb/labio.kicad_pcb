# Repository ihartwig/rpi-labio (continued)

## KiCad design pcb/labio.kicad_pcb (continued)

Schematic: labio-mech.sch, Raspberry Pi Embedded Lab I/O

Parts:
G1: CMU_LOGO; cmu_logo_fsilk_3.7mm
G2: WISE_LOGO; wise_logo_fsilk_2.5mm
G3: CMU_LOGO; cmu_logo_fcu_3.7mm
G4: WISE_LOGO; wise_logo_fcu_2.5mm
H1001, H1002, H1003, H1004, H1005, H1006, H1007, H1008, H1009: hole; hole-m3

Notes on the sheet:
RPi-like Mounting Holes M3 for M3/no 4/M2.5 hardware.
Heatsink Mounting 25x25mm with 30x30mm M3 holes

Board: 2 copper layers, 152.0 x 85.0 mm, 234 parts (8 on the bottom side), 160 nets.

File pcb/labio.bom.csv (part):

Source,/Users/ihartwig/repos/rpi-labio/pcb/labio.sch
Kicad Rev,Eeschema 4.0.0-stable
Generated Date,Tuesday, July 26, 2016 'AMt' 01:45:02 AM

Title,Not Set
Company,Not Set
Revision,Not Set
Date Issue,Not Set

Reference,Value,Footprint,Library,Library Ref
P1,CONN_02X20,labio-special:Pin_Header_Straight_TH-SMT-NoPaste_2x20,conn,CONN_02X20
IC201,dnp-AT24CS32-XHM,Housings_SSOP:TSSOP-8_4.4x3mm_Pitch0.65mm,memory,AT24CS32-XHM
R203,dnp-10k,Resistors_SMD:R_0603,device,R_Small
R204,dnp-3.9k,Resistors_SMD:R_0603,device,R_Small
R205,dnp-3.9k,Resistors_SMD:R_0603,device,R_Small
W202,TEST_1P,Measurement_Points:Measurement_Point_Round-SMD-Pad_Small,conn,TEST_1P
W201,TEST_1P,Measurement_Points:Measurement_Point_Round-SMD-Pad_Small,conn,TEST_1P
R202,4.7k,Resistors_SMD:R_0603,device,R_Small
R201,4.7k,Resistors_SMD:R_0603,device,R_Small
U201,AP7365_SOT-23-5,TO_SOT_Packages_SMD:SOT-23-5,labio-special,AP7365_SOT-23-5
C201,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C202,0.1uF,Capacitors_SMD:C_0603,device,C_Small
U301,ADS1015,Housings_SSOP:MSOP-10_3x3mm_Pitch0.5mm,labio-special,ADS1015
P301,CONN_01X04,Pin_Headers:Pin_Header_Straight_1x04,conn,CONN_01X04
P302,CONN_01X04,Pin_Headers:Pin_Header_Straight_1x04,conn,CONN_01X04
P303,CONN_01X04,Pin_Headers:Pin_Header_Straight_1x04,conn,CONN_01X04
C301,0.1uF,Capacitors_SMD:C_0603,device,C_Small
Q301,PHOTOTRANSISTOR,LEDs:LED-0603,labio-special,PHOTOTRANSISTOR
R301,1.5k,Resistors_SMD:R_0603,device,R_Small
SW301,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
D301,Led_Small,LEDs:LED-0603,device,Led_Small
R302,220,Resistors_SMD:R_0603,device,R_Small
Q303,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
Q302,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R304,10k,Resistors_SMD:R_0603,device,R_Small
R303,10k,Resistors_SMD:R_0603,device,R_Small
P401,SFV12R-1ST__HLF,labio-special:SFVxxR-xSTxxHLF,conn,CONN_01X12
R401,0,Resistors_SMD:R_0603,device,R_Small
SW401,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
R403,0,Resistors_SMD:R_0603,device,R_Small
R402,0,Resistors_SMD:R_0603,device,R_Small
C505,4.7uF,Capacitors_SMD:C_0805,device,C_Small
C503,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C502,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C506,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C504,0.1uF,Capacitors_SMD:C_0603,device,C_Small
SW501,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
D501,Led_Small,LEDs:LED-0603,device,Led_Small
R501,220,Resistors_SMD:R_0603,device,R_Small
C501,4.7uF,Capacitors_SMD:C_0805,device,C_Small
U501,LSM303D,labio-special:LGA-16_3x3mm_Pitch0.5mm_ST,labio-special,LSM303D
C513,0.22uF,Capacitors_SMD:C_0603,device,C_Small
U502,BMP280,labio-special:LGA-8_2.5x2.0mm_Pitch0.65mm_BMx280,labio-special,BMP280
R509,0,Resistors_SMD:R_0603,device,R_Small
R513,0,Resistors_SMD:R_0603,device,R_Small
R506,0,Resistors_SMD:R_0603,device,R_Small
R508,0,Resistors_SMD:R_0603,device,R_Small
R512,dnp-0,Resistors_SMD:R_0603,device,R_Small
C512,0.01uF-25V,Capacitors_SMD:C_0603,device,C_Small
C511,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C510,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C509,4.7uF,Capacitors_SMD:C_0805,device,C_Small
R511,0,Resistors_SMD:R_0603,device,R_Small
R515,0,Resistors_SMD:R_0603,device,R_Small
R507,0,Resistors_SMD:R_0603,device,R_Small
R510,0,Resistors_SMD:R_0603,device,R_Small
R514,dnp-0,Resistors_SMD:R_0603,device,R_Small
U503,L3GD20H,labio-special:LGA-16_3x3mm_Pitch0.5mm_ST,labio-special,L3GD20H
R505,0,Resistors_SMD:R_0603,device,R_Small
C508,4.7uF,Capacitors_SMD:C_0805,device,C_Small
C507,4.7uF,Capacitors_SMD:C_0805,device,C_Small
R502,0,Resistors_SMD:R_0603,device,R_Small
R503,dnp-0,Resistors_SMD:R_0603,device,R_Small
R504,0,Resistors_SMD:R_0603,device,R_Small
P605,CONN_01X03,Pin_Headers:Pin_Header_Straight_1x03,conn,CONN_01X03
P606,CONN_01X03,Pin_Headers:Pin_Header_Straight_1x03,conn,CONN_01X03
P607,CONN_01X05,Pin_Headers:Pin_Header_Straight_1x05,conn,CONN_01X05
P608,CONN_01X05,Pin_Headers:Pin_Header_Straight_1x05,conn,CONN_01X05
P601,CONN_01X02,labio-special:Pin_Header_Straight_1x02_Pitch3.5mm,conn,CONN_01X02
P602,CONN_01X02,labio-special:Pin_Header_Straight_1x02_Pitch3.5mm,conn,CONN_01X02
P604,CONN_01X02,labio-special:Pin_Header_Straight_1x02_Pitch3.5mm,conn,CONN_01X02
C601,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C602,0.1uF,Capacitors_SMD:C_0603,device,C_Small
C603,47uF,Capacitors_SMD:c_elec_6.3x5.8,device,CP_Small
C604,47uF,Capacitors_SMD:c_elec_6.3x5.8,device,CP_Small
D620,D_Small,Diodes_SMD:SOD-523,device,D_Small
D619,D_Small,Diodes_SMD:SOD-523,device,D_Small
D618,D_Small,Diodes_SMD:SOD-523,device,D_Small
D621,D_Small,Diodes_SMD:SOD-523,device,D_Small
D622,D_Small,Diodes_SMD:SOD-523,device,D_Small
D623,D_Small,Diodes_SMD:SOD-523,device,D_Small
SW601,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
SW602,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
R614,0.01,Resistors_SMD:R_1206,device,R_Small
R615,0.01,Resistors_SMD:R_1206,device,R_Small
R608,20k,Resistors_SMD:R_0603,device,R_Small
R609,20k,Resistors_SMD:R_0603,device,R_Small
R602,1k,Resistors_SMD:R_0603,device,R_Small
R601,1k,Resistors_SMD:R_0603,device,R_Small
SW603,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
D611,D_Small,Diodes_SMD:SOD-523,device,D_Small
D612,D_Small,Diodes_SMD:SOD-523,device,D_Small
D613,D_Small,Diodes_SMD:SOD-523,device,D_Small
SW606,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
D624,D_Small,Diodes_SMD:SOD-523,device,D_Small
D625,D_Small,Diodes_SMD:SOD-523,device,D_Small
D626,D_Small,Diodes_SMD:SOD-523,device,D_Small
P603,CONN_01X04,Pin_Headers:Pin_Header_Straight_1x04,conn,CONN_01X04
D602,Led_Small,LEDs:LED-0603,device,Led_Small
Q601,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R605,220,Resistors_SMD:R_0603,device,R_Small
R603,20k,Resistors_SMD:R_0603,device,R_Small
D603,Led_Small,LEDs:LED-0603,device,Led_Small
Q602,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R606,220,Resistors_SMD:R_0603,device,R_Small
R604,20k,Resistors_SMD:R_0603,device,R_Small
SW604,DIP_SWITCH_X04,labio-special:DIP-8_W7.62mm_SMT,labio-special,DIP_SWITCH_X04
D604,Led_Small,LEDs:LED-0603,device,Led_Small
Q603,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R612,220,Resistors_SMD:R_0603,device,R_Small
R610,20k,Resistors_SMD:R_0603,device,R_Small
D605,Led_Small,LEDs:LED-0603,device,Led_Small
Q604,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R613,220,Resistors_SMD:R_0603,device,R_Small
R611,20k,Resistors_SMD:R_0603,device,R_Small
D606,Led_Small,LEDs:LED-0603,device,Led_Small
Q605,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R618,220,Resistors_SMD:R_0603,device,R_Small
R616,20k,Resistors_SMD:R_0603,device,R_Small
D607,Led_Small,LEDs:LED-0603,device,Led_Small
Q606,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R619,220,Resistors_SMD:R_0603,device,R_Small
R617,20k,Resistors_SMD:R_0603,device,R_Small
D608,Led_Small,LEDs:LED-0603,device,Led_Small
Q607,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R622,220,Resistors_SMD:R_0603,device,R_Small
R620,20k,Resistors_SMD:R_0603,device,R_Small
D609,Led_Small,LEDs:LED-0603,device,Led_Small
Q608,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R623,220,Resistors_SMD:R_0603,device,R_Small
R621,20k,Resistors_SMD:R_0603,device,R_Small
D614,Led_Small,LEDs:LED-0603,device,Led_Small
Q609,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R626,220,Resistors_SMD:R_0603,device,R_Small
R625,20k,Resistors_SMD:R_0603,device,R_Small
D616,Led_Small,LEDs:LED-0603,device,Led_Small
Q610,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R630,220,Resistors_SMD:R_0603,device,R_Small
R628,20k,Resistors_SMD:R_0603,device,R_Small
D627,Led_Small,LEDs:LED-0603,device,Led_Small
Q612,Q_NMOS_GSD,TO_SOT_Packages_SMD:SOT-23,device,Q_NMOS_GSD
R634,220,Resistors_SMD:R_0603,device,R_Small
R632,20k,Resistors_SMD:R_0603,device,R_Small
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
## Commit log

2016-06-11 schematic pages for rpi header, adc, audio
2016-06-11 add schematics for display and dio (dpad, servo, motor, encoder)
2016-06-19 add imu sensors, make top level connections
2016-06-24 finish rpi to module connections
    * use dip switches to disable/configure blocks
    * add light sensor
    * fix motor controller sense resistors
    * fix overused jtag probe pins
2016-06-25 add led status indicators, rotary encoder
    * add led indicators for motor direction, pwm, encoder (muxed with dpad) pins
    * add led indicators for power in all blocks
    * split dpad into a different page
    * add selectable onboard rotary encoder for testing or user input
2016-07-03 make extra footprints. start floorplan. fix display nets. add power expansion header.
2016-07-10 floorplan on 150x85mm board, use al caps for motors
2016-07-16 first pass routing, fixed audio header 3v3 net
2016-07-18 update imu parts, adc rails, motor headers
    * replace LSM303C accelerometer with LSM303D for better sensor ranges at same cost.
    * add L3GD20H gyroscope so we have a 10-DOF imu. consider leaving depopulated for complexity.
    * add 0 ohms to accel/gyro address and interrupt pins in case of later changes
    * change ADC rails to 5V to read 5V power shunts. add level shifters to the 3.3V I2C bus.
    * use 3.5mm pitch headers for motor terminal blocks to accept higher guage wire.
    todo:
2016-07-19 finish rerouting for new parts
    * fix adc power supply nets
    * redo adc layout
    * move motor controller up to make space for headers
    * add motor controller heatsink mount
    * fix motor controller ground pad net
    todo:
2016-07-19 combine gnd and gnda nets per mixed signal layout suggestions from analog, ti
2016-07-20 expand outline to 175x85mm. move screen zif connector to top
2016-07-24 shrink board to 85x150mm with tab board under rpi 0/debugger
    * use space under rpi 0/debugger for imu since no visibility is needed
    * rearrange dpad buttons and speaker to be more compact
    * use 3V3_EXTRA for i2c pullups for consistency
    * add bottom right hole to match future power module
2016-07-25 add cmu + wise logos, clean up silk, review for final errors
    * move audio jack in so copper pads are inside board
    * add logos/identifier text on silk and copper
    * change rpi connector for no paste (to be left depopulated at fab)
    * change soldermask expansion to 2 mils/3 mils minimum width
    * add labels for motor, ADC, codec headers
2016-07-25 update readme, export only board in svg
2016-07-26 add bom. change led resistors to 220 and dnp rpi hat eeprom
2016-08-01 Fix board/bom errors from initial build
    * Accelerometer (U501) footprint mirrored. Redraw footprint and adjust routing.
    * Gyro (U505) footprint mirrored. Redraw footprint and adjust routing.
    * Codec (U702) labed as wrong chip. Says WM8731 but should be 8750. Also fix in BOM.
    * Should include OLED screen in BOM (not just the connector).
    * Codec to TRRS caps have incorrect value. Says 220uF but should be 220pF.
    * Mark RPi Hat EEPROM circuit as depopulated in schematic.
2016-08-01 Use soldermask windows on footprints with thermal pads (motor driver, codec)
2016-08-02 improve codec and motor driver soldermask windows to avoid convex 90 deg angles
2016-08-05 Power motor driver from 5V but with 3.3V logic. Adjust R601, R602 to prevent more than 3.3V on logic lines.
2016-08-06 add fuses for connectable headers (adc, encoder, motors, servo, codec). GERBER/BOM UPDATES ONLY
2016-08-11 fix codec/mic/trrs bias circuit
    * trrs (headset) mic bias was flipped (in vs out) from datasheet
    * trrs l/r decoupling caps changed back to 220uF per datasheet and re-layout for 1210 ceramic
    * mems mic decoupling changed to 1uF for consistency
2016-08-14 Fix ADC reading mic, possible backpowering, encoder pull downs, vias in footprint:
    * Mic needs on-board path to ADC. Add proper bias and amp. Connect to ADC or codec with switches.
    * Mic footprint (U701) flipped. Redraw footprint and adjust routing.
    * Remove power from dip switches and replace with fuses. Turning power off to a block could result in backpower from driven IO lines.
    * Remove/adjust pull downs on LEDs for encoder/dpad lines.
    * Move vias out of display connector (P401) footprint.
2016-08-14 adjust vdd servo, vdd codec pours
2016-08-15 Fix i2c addresses, pressure sensor footprint, consolidate BOM
    * Schematic should list I2C addresses for accelerometer, gyro.
    * Pressure sensor footprint (U502) has pins in the wrong order. Redraw footprint and adjust routing.
    * Bump i2c and photodiode pullups to 2.2k
    * Remove R505 near gyro
2016-08-15 add pdf schematic for a154e58
2016-08-20 using MISO/gpio for D/C on led screen and layout. bump to rev 1.2.0.
2016-08-22 fix parts missing from bom (using pos export) and fill in passive part nos
2016-08-24 add options for driving oled reset. no changes to stuffed bom parts.
2016-08-24 add through hole parts to the bom (highlighted). update schematic pdf.
2016-10-26 fix bom qty for P601 P602 P604 (screw in header)
2017-08-02 add prelim cover design and explaination
2017-08-04 complete cover designs b/c/d for prototyping
2017-08-07 finish pi 2 top cover. arrange cover sets for cutting protos.
2017-08-13 fix cover details after first proto. add set a cut files.
    * don't cover d-pad buttons
    * expand area around screen
    * expand area around pi 2/3 ribbon connectors
    * pi 2/3 cutouts for caps near ports
    * expand area around sd card
    * complete set a mounting holes
2017-08-20 complete cover BOM, fixes, and cutting sets. refresh readmes
    add cutting sets for C and D covers
    fix pi 2/3 usb port on cover
    complete cover BOM with part links
2017-11-24 Updated LICENSE
