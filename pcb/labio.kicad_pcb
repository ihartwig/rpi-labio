# Repository ihartwig/rpi-labio

File README.md:

# rpi-labio

Together with the JTAG debugger and cover with motor mounts, this Raspberry Pi breakout board forms a complete kit for embedded systems labs in ARM baremetal and linux. This kit has been used for several semesters at [CMU ECE](https://www.ece.cmu.edu/~ece349/).

</img>

</img>

This single, compact board extends a Raspberry Pi 0 or 2 for a full range of labs combining embedded processing with real-world sensors and transducers. All parts are optional and can be disconnected in favor of other plugged in hardware. Together, the sensor kit exercises almost all serial and digital I/O available on the Raspberry Pi. For more details check out the [schematic](https://github.com/ihartwig/rpi-labio/blob/master/pcb/labio.pdf) and [board](https://github.com/ihartwig/rpi-labio/blob/master/pcb/svg/labio-brd.svg).

## I/O

* OLED Display
* 10-DOF IMU (Accelerometer + Compass + Gyroscope + Pressure)
* Audio Codec with speaker, microphone, and headset port
* D-Pad Buttons
* Servo Headers with configurable voltage
* Full-Bridge for 2 DC motors or 1 stepper motor
* Encoder Headers with configurable voltage
* Rotary Encoder
* ADC with optional differential amplifier
* LED indicators on most digital outputs

## Example Labs

* Arcade style games with screen, d-pad, and rotary encoder
* Guitar tuner with microphone, speaker, codec, and screen
* MP3 player with codec and headphone port
* The useless machine with servo and buttons
* Self-balancing robot with IMU, motor controller, and encoders
* Energy-aware computing with ADC and power shunt (on board for motors, off board for RPi)
* And more!

## KiCad design pcb/labio.kicad_pcb

Notes on the sheet:
JTAG Probe
GPIO Inputs
I2S Audio / GPIO Outputs
I2C
UART
SPI
Use MISO as output to support 4-wire SPI. MUST change to input on CS deassert for other SPI devs.

Parts:
C201, C202: 0.1uF; C_0603
IC201: dnp-AT24CS32-XHM; TSSOP-8_4.4x3mm_Pitch0.65mm
P201: CONN_02X20; Pin_Header_Straight_TH-SMT-NoPaste_2x20
R201, R202: 2.2k; R_0603
R203: dnp-10k; R_0603
R204, R205: dnp-3.9k; R_0603
U201: AP7365_SOT-23-5; SOT-23-5
W201, W202: TEST_1P; Measurement_Point_Round-SMD-Pad_Small

Connections:
/3V3_EXTRA: C202.1, R201.1, R202.1, U201.5 (VOUT); also elsewhere on the board
/5V: C201.1, P201.2, P201.4, U201.1 (VIN), U201.3 (EN); also elsewhere on the board
/GPCLK1: P201.29; also elsewhere on the board
/I2C_INT: P201.31; also elsewhere on the board
/I2C_SCL: P201.5, R202.2; also elsewhere on the board
/I2C_SDA: P201.3, R201.2; also elsewhere on the board
/I2S_BCLK: P201.12; also elsewhere on the board
/I2S_LRCLK: P201.35; also elsewhere on the board
/I2S_SDIN: P201.40; also elsewhere on the board
/I2S_SDOUT: P201.38; also elsewhere on the board
/PWM0: P201.32; also elsewhere on the board
/PWM1: P201.33; also elsewhere on the board
/labio-display/DC: P201.21; also elsewhere on the board
/labio-dpad/DPAD_CENTER: P201.11; also elsewhere on the board
/labio-dpad/DPAD_DOWN: P201.37; also elsewhere on the board
/labio-dpad/DPAD_LEFT: P201.26; also elsewhere on the board
/labio-dpad/DPAD_RIGHT: P201.16; also elsewhere on the board
/labio-dpad/DPAD_UP: P201.36; also elsewhere on the board
/labio-rpi/3V3_1: P201.1
/labio-rpi/3V3_2: IC201.8 (VCC), P201.17, R203.1, R204.1, R205.1
/labio-rpi/GPIO4: P201.7
/labio-rpi/GPIO8_SPI0_CE0_N: P201.24; also elsewhere on the board
/labio-rpi/GPIO10_SPI0_MOSI: P201.19; also elsewhere on the board
/labio-rpi/GPIO11_SPI0_SCLK: P201.23; also elsewhere on the board
/labio-rpi/GPIO14_TXD: P201.8
/labio-rpi/GPIO15_RXD: P201.10
/labio-rpi/GPIO22: P201.15
/labio-rpi/GPIO24: P201.18
/labio-rpi/GPIO25: P201.22
/labio-rpi/GPIO27: P201.13
/labio-rpi/ID_SC: IC201.6 (SCL), P201.28, R205.2
/labio-rpi/ID_SD: IC201.5 (SDA), P201.27, R204.2
GND: C201.2, C202.2, IC201.1 (A0), IC201.2 (A1), IC201.3 (A2), IC201.4 (GND), P201.6, P201.9, P201.14, P201.20, P201.25, P201.30, P201.34, P201.39, U201.2 (GND), W201.1; also elsewhere on the board
unnamed: IC201.7 (WP), R203.2, W202.1

Notes on the sheet:
RPi HAT EEPROM
Extra 3.3V Supply

Parts:
C301: 0.1uF; C_0603
D301: Led_Small; LED-0603
F301: F_Small; R_1206
P301, P302, P303: CONN_01X04; Pin_Header_Straight_1x04
Q301: PHOTOTRANSISTOR; LED-0603
Q302, Q303: Q_NMOS_GSD; SOT-23
R301: 2.2k; R_0603
R302: 220; R_0603
R303, R304: 10k; R_0603
SW301: DIP_SWITCH_X04; DIP-8_W7.62mm_SMT
U301: ADS1015; MSOP-10_3x3mm_Pitch0.5mm

Connections:
/3V3_EXTRA: Q302.1 (G), Q303.1 (G); also elsewhere on the board
/5V: F301.2; also elsewhere on the board
/I2C_INT: SW301.7 (2A); also elsewhere on the board
/I2C_SCL: SW301.5 (4B); also elsewhere on the board
/I2C_SDA: SW301.6 (3B); also elsewhere on the board
/labio-adc/ADC_AIN0: P303.1, U301.4 (AIN0)
/labio-adc/ADC_AIN1: P303.2, U301.5 (AIN1)
/labio-adc/ADC_AIN2: P303.3, SW301.1 (1A), U301.6 (AIN2)
/labio-adc/ADC_AIN3: P303.4, Q301.2 (C), R301.2, U301.7 (AIN3)
/labio-adc/INT_J: SW301.2 (2A), U301.2 (ALERT)
/labio-adc/SCL_5V: Q302.3 (D), R303.2, U301.10 (SCL)
/labio-adc/SCL_J: Q302.2 (S), SW301.4 (4A)
/labio-adc/SDA_5V: Q303.3 (D), R304.2, U301.9 (SDA)
/labio-adc/SDA_J: Q303.2 (S), SW301.3 (3A)
/labio-adc/VDD5V_J: C301.1, D301.2 (A), F301.1, P302.1, P302.2, P302.3, P302.4, R301.1, R303.1, R304.1, U301.1 (ADDR), U301.8 (VDD)
GND: C301.2, P301.1, P301.2, P301.3, P301.4, Q301.1 (E), R302.2, U301.3 (GND); also elsewhere on the board
MEMS_MIC_TO_ADC: SW301.8 (1B); also elsewhere on the board
unnamed: D301.1 (K), R302.1

Notes on the sheet:
12-bit (ADS1015) or 16-bit (ADS1115) ADC with differential PGA and 4-channel mux. 7-bit addr: 0x73 5V VDD to safely sample RPi VBUS.
Light Sensor
5V <=> 3.3V level shifting

Parts:
F401: F_Small; R_1206
P401: SFV12R-1ST__HLF; SFVxxR-xSTxxHLF
R401, R402, R403: 0; R_0603
SW401: DIP_SWITCH_X04; DIP-8_W7.62mm_SMT
U401: CFAL12832D-B

Connections:
/3V3_EXTRA: F401.1; also elsewhere on the board
/labio-display/DC: SW401.2 (2A); also elsewhere on the board
/labio-display/OLED_BS0: P401.4, R403.1
/labio-display/OLED_BS1: P401.5, R402.1
/labio-display/OLED_DC: P401.8, SW401.7 (2A)
/labio-display/OLED_MOSI: P401.10, SW401.5 (4B)
/labio-display/OLED_SCK: P401.9, SW401.6 (3B)
/labio-display/~OLED_CS: P401.6, SW401.8 (1B)
/labio-display/~OLED_RES: P401.7, R401.1
/labio-rpi/GPIO8_SPI0_CE0_N: SW401.1 (1A); also elsewhere on the board
/labio-rpi/GPIO10_SPI0_MOSI: SW401.4 (4A); also elsewhere on the board
/labio-rpi/GPIO11_SPI0_SCLK: SW401.3 (3A); also elsewhere on the board
GND: P401.1, P401.12, R402.2; also elsewhere on the board
unnamed: F401.2, P401.2, P401.3, R401.2, R403.2

Notes on the sheet:
CFAL12832D-B* OLED Display 3-wire SPI mode. Note: top side ZIF connector has pins reversed from FPC.
20mA approx max
FPC 1
FPC 12

Parts:
C501, C505, C507, C508, C509: 4.7uF; C_0805
C502, C503, C504, C506, C510, C511: 0.1uF; C_0603
C512: 0.01uF-25V; C_0603
C513: 0.22uF; C_0603
D501: Led_Small; LED-0603
F501: F_Small; R_1206
R501: 220; R_0603
R502, R504, R506, R507, R508, R509, R510, R511, R513, R515: 0; R_0603
R503, R512, R514: dnp-0; R_0603
SW501: DIP_SWITCH_X04; DIP-8_W7.62mm_SMT
U501: LSM303D; LGA-16_3x3mm_Pitch0.5mm_ST
U502: BMP280; LGA-8_2.5x2.0mm_Pitch0.65mm_BMx280
U503: L3GD20H; LGA-16_3x3mm_Pitch0.5mm_ST

Connections:
/3V3_EXTRA: F501.2; also elsewhere on the board
/I2C_INT: SW501.5 (4B); also elsewhere on the board
/I2C_SCL: SW501.7 (2A); also elsewhere on the board
/I2C_SDA: SW501.6 (3B); also elsewhere on the board
/labio-imu/ACCEL_CS: R508.2, U501.8 (CS)
/labio-imu/ACCEL_INT1: R509.1, U501.11 (INT1)
/labio-imu/ACCEL_INT2: R506.1, U501.9 (INT2)
/labio-imu/ACCEL_SA0: R512.2, R513.1, U501.7 (SA0/SDO)
/labio-imu/BMP_ADDR: R503.2, R504.1, U502.5 (ADDR/SDO)
/labio-imu/BMP_CS: R502.2, U502.2 (CSB)
/labio-imu/GYRO_CS: R510.2, U503.5 (CS)
/labio-imu/GYRO_INT1: R511.1, U503.7 (INT1)
/labio-imu/GYRO_INT2: R507.1, U503.6 (DRDY/INT2)
/labio-imu/GYRO_SA0: R514.2, R515.1, U503.4 (SA0/SDO)
/labio-imu/INT_J: R506.2, R507.2, R509.2, R511.2, SW501.4 (4A)
/labio-imu/SCL_J: SW501.2 (2A), U501.4 (SCL/SPC), U502.4 (SCL/SCK), U503.2 (SCL/SPC)
/labio-imu/SDA_J: SW501.3 (3A), U501.6 (SDA/SDI/SDO), U502.3 (SDA/SDI), U503.3 (SDA/SDI/SDO)
/labio-imu/VDD3V3_J: C501.1, C502.1, C503.1, C504.1, C506.1, C507.1, C508.1, C509.1, C510.1, C511.1, D501.2 (A), F501.1, R502.1, R503.1, R508.1, R510.1, R512.1, R514.1, U501.1 (VDDIO), U501.14 (VDD), U502.6 (VDDIO), U502.8 (VDD), U503.1 (VDDIO), U503.16 (VDD)
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, R501.2, R504.2, R513.2, R515.2, U501.5 (GND), U501.10 (RSVD), U501.12 (GND), U501.13 (GND), U501.16 (GND), U502.1 (GND), U502.7 (GND), U503.8 (DEN), U503.9 (RSVD), U503.10 (RSVD), U503.11 (RSVD), U503.12 (GND), U503.13 (GND), U503.15 (RSVD); also elsewhere on the board
unnamed: C505.1, U501.15 (C1)
unnamed: C512.1, U503.14 (CAP)
unnamed: C513.1, U501.2 (SETC)
unnamed: C513.2, U501.3 (SETP)
unnamed: D501.1 (K), R501.1

Notes on the sheet:
6-DOF Accelerometer + Compass Keep currents higher than 10mA a few mm away from compass. 7-bit I2C Addr: 0x1E (0011110)
Pressure + Temperature 7-bit I2C Addr: 0x76 (1110110)
0.5mA max
1mA max
3-DOF Gyroscope 7-bit I2C Addr: 0x6A (1101010)

Parts:
C601, C602, C605, C606, C607: 0.1uF; C_0603
C603, C604, C608, C609: 47uF; c_elec_6.3x5.8
D601, D602, D603, D604, D605, D606, D607, D608, D609, D610, D614, D615, D616, D617, D627, D628: Led_Small; LED-0603
D611, D612, D613, D618, D619, D620, D621, D622, D623, D624, D625, D626: D_Small; SOD-523
F601: F_Small; OMNI-BLOCK_Fuse_10x5mm_Littelfuse
F602, F603, F604: F_Small; R_1206
P601, P602, P604: CONN_01X02; Pin_Header_Straight_1x02_Pitch3.5mm
P603: CONN_01X04; Pin_Header_Straight_1x04
P605, P606: CONN_01X03; Pin_Header_Straight_1x03
P607, P608: CONN_01X05; Pin_Header_Straight_1x05
Q601, Q602, Q603, Q604, Q605, Q606, Q607, Q608, Q609, Q610, Q611, Q612, Q613: Q_NMOS_GSD; SOT-23
R601, R602: 10k; R_0603
R603, R604, R608, R609, R610, R611, R616, R617, R620, R621, R625, R628, R629, R632, R633: 20k; R_0603
R605, R606, R607, R612, R613, R618, R619, R622, R623, R624, R626, R627, R630, R631, R634, R635: 220; R_0603
R614, R615: 0.01; R_1206
SW601, SW602, SW603, SW604, SW606: DIP_SWITCH_X04; DIP-8_W7.62mm_SMT
SW605: ROT_ENC; Rot-Enc-12mm-Horiz-Button
U601: L298P_PowerSO20; PowerSO20

Connections:
/3V3_EXTRA: D602.2 (A), D603.2 (A), D604.2 (A), D605.2 (A), D606.2 (A), D607.2 (A), D608.2 (A), D609.2 (A), D614.2 (A), D616.2 (A), D617.2 (A), D627.2 (A), D628.2 (A), R620.2, R621.2, R625.2, R628.2, R629.2, R632.2, SW603.3 (3A), SW606.3 (3A); also elsewhere on the board
/5V: F604.1, SW603.2 (2A), SW606.2 (2A); also elsewhere on the board
/I2C_INT: D619.2 (A), Q607.1 (G), R620.1; also elsewhere on the board
/I2S_BCLK: Q604.1 (G), R611.1, SW601.4 (4A); also elsewhere on the board
/I2S_LRCLK: Q603.1 (G), R610.1, SW601.3 (3A); also elsewhere on the board
/I2S_SDIN: Q601.1 (G), R603.1, SW601.1 (1A); also elsewhere on the board
/I2S_SDOUT: Q602.1 (G), R604.1, SW601.2 (2A); also elsewhere on the board
/PWM0: P605.3, Q605.1 (G), R616.1, SW602.1 (1A); also elsewhere on the board
/PWM1: P606.3, Q606.1 (G), R617.1, SW602.3 (3A); also elsewhere on the board
/labio-dio/ENC0_A_D: D619.1 (K), P607.3
/labio-dio/ENC0_B_D: D618.1 (K), P607.5
/labio-dio/ENC0_IDX_D: D620.1 (K), P607.2
/labio-dio/ENC1_A_D: D622.1 (K), P608.3
/labio-dio/ENC1_B_D: D621.1 (K), P608.5
/labio-dio/ENC1_IDX_D: D623.1 (K), P608.2
/labio-dio/MOTOR_OUT1: P601.1, U601.4 (OUT1)
/labio-dio/MOTOR_OUT2: P601.2, U601.5 (OUT2)
/labio-dio/MOTOR_OUT3: P602.1, U601.16 (OUT3)
/labio-dio/MOTOR_OUT4: P602.2, U601.17 (OUT4)
/labio-dio/MOTOR_SENSEA: P603.1, R615.1, U601.2 (SENSEA)
/labio-dio/MOTOR_SENSEB: P603.3, R614.1, U601.19 (SENSEB)
/labio-dio/MOT_ENA: R608.1, SW602.7 (2A), SW602.8 (1B), U601.8 (ENABLEA)
/labio-dio/MOT_ENB: R609.1, SW602.5 (4B), SW602.6 (3B), U601.14 (ENABLEB)
/labio-dio/MOT_IN1_J: SW601.8 (1B), U601.7 (IN1)
/labio-dio/MOT_IN2_J: SW601.7 (2A), U601.9 (IN2)
/labio-dio/MOT_IN3_J: SW601.6 (3B), U601.13 (IN3)
/labio-dio/MOT_IN4_J: SW601.5 (4B), U601.15 (IN4)
/labio-dio/VDD_ENC: D615.2 (A), F603.2, P607.4, P608.4
/labio-dio/VDD_ENC_F: D624.1 (K), D625.1 (K), D626.1 (K), F603.1
/labio-dio/VDD_MOT: C601.1, D601.2 (A), F604.2, R601.1, R602.1, U601.12 (VSS)
/labio-dio/VDD_SERVO: C608.1, C609.1, D610.2 (A), F602.2, P605.2, P606.2
/labio-dio/VDD_SERVO_F: D611.1 (K), D612.1 (K), D613.1 (K), F602.1
/labio-dio/VS_MOTOR: C603.1, C604.1, F601.1, P604.1, Q613.1 (G), R633.1, SW603.1 (1A), SW606.1 (1A); also elsewhere on the board
/labio-dio/VS_MOTOR_F: C602.1, F601.2, U601.6 (VS)
/labio-dpad/DPAD_CENTER: D622.2 (A), Q610.1 (G), R628.1, SW604.3 (3A); also elsewhere on the board
/labio-dpad/DPAD_DOWN: D623.2 (A), Q612.1 (G), R632.1, SW604.2 (2A); also elsewhere on the board
/labio-dpad/DPAD_LEFT: D618.2 (A), Q608.1 (G), R621.1; also elsewhere on the board
/labio-dpad/DPAD_RIGHT: D621.2 (A), Q611.1 (G), R629.1, SW604.4 (4A); also elsewhere on the board
/labio-dpad/DPAD_UP: D620.2 (A), Q609.1 (G), R625.1; also elsewhere on the board
GND: C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, P603.2, P603.4, P604.2, P605.1, P606.1, P607.1, P608.1, Q601.2 (S), Q602.2 (S), Q603.2 (S), Q604.2 (S), Q605.2 (S), Q606.2 (S), Q607.2 (S), Q608.2 (S), Q609.2 (S), Q610.2 (S), Q611.2 (S), Q612.2 (S), Q613.2 (S), R603.2, R604.2, R607.2, R608.2, R609.2, R610.2, R611.2, R614.2, R615.2, R616.2, R617.2, R624.2, R627.2, R633.2, SW605.2 (C), SW605.4 (E), U601.1 (GND), U601.10 (GND), U601.11 (GND), U601.20 (GND), U601.21 (PAD); also elsewhere on the board
unnamed: C605.1, SW604.7 (2A), SW605.5 (D)
unnamed: C606.1, SW604.6 (3B), SW605.1 (A)
unnamed: C607.1, SW604.5 (4B), SW605.3 (B)
unnamed: D601.1 (K), R607.1
unnamed: D602.1 (K), R605.1
unnamed: D603.1 (K), R606.1
unnamed: D604.1 (K), R612.1
unnamed: D605.1 (K), R613.1
unnamed: D606.1 (K), R618.1
unnamed: D607.1 (K), R619.1
unnamed: D608.1 (K), R622.1
unnamed: D609.1 (K), R623.1
unnamed: D610.1 (K), R624.1
unnamed: D611.2 (A), SW603.8 (1B)
unnamed: D612.2 (A), SW603.7 (2A)
unnamed: D613.2 (A), SW603.6 (3B)
unnamed: D614.1 (K), R626.1
unnamed: D615.1 (K), R627.1
unnamed: D616.1 (K), R630.1
unnamed: D617.1 (K), R631.1
unnamed: D624.2 (A), SW606.8 (1B)
unnamed: D625.2 (A), SW606.7 (2A)
unnamed: D626.2 (A), SW606.6 (3B)
unnamed: D627.1 (K), R634.1
unnamed: D628.1 (K), R635.1
unnamed: Q601.3 (D), R605.2
unnamed: Q602.3 (D), R606.2
unnamed: Q603.3 (D), R612.2
unnamed: Q604.3 (D), R613.2
unnamed: Q605.3 (D), R618.2
unnamed: Q606.3 (D), R619.2
unnamed: Q607.3 (D), R622.2
unnamed: Q608.3 (D), R623.2
unnamed: Q609.3 (D), R626.2
unnamed: Q610.3 (D), R630.2
unnamed: Q611.3 (D), R631.2
unnamed: Q612.3 (D), R634.2
unnamed: Q613.3 (D), R635.2
unnamed: R601.2, SW602.4 (4A)
unnamed: R602.2, SW602.2 (2A)

Notes on the sheet:
Quadrature Encoder Pins US Digital S1 Pinout. Jumper for power source. Diodes for 5V levels and multiplexing. Use RPi pull-ups.
Servo Pins Ground, voltage, signal headers. Jumper for power source.
Motor Driver 2x DC Motors or 1x Bipolor Stepper Motor
LED Indicators
Quadrature Encoder (onboard) Use RPi pull-ups.
Pull up to max 3.3V to protect RPi.

Parts:
C701, C703, C705, C707, C708, C710, C713, C717, C721: 0.1uF; C_0603
C702, C706, C712, C716, C718: 4.7uF; C_0805
C704, C711, C719, C720: 1uF; C_0603
C709: 220pF; C_0603
C714, C715: 220uF; C_1210
D701: Led_Small; LED-0603
F701: F_Small; R_1206
J701: JACK_TRRS_6PINS; 3.5mm-Jack-CUI-SJ-4351X
P701, P702, P703: CONN_01X04; Pin_Header_Straight_1x04
P704: CONN_01X02; Pin_Header_Straight_1x02
R701: 220; R_0603
R702: 47k; R_0603
R703: 2.2k; R_0603
R704, R705, R706: 10k; R_0603
R707: 820k; R_0603
SW701, SW702: DIP_SWITCH_X04; DIP-8_W7.62mm_SMT
U701: SPU0410HR5H
U702: WM8750; QFN-32-1EP_5x5mm_Pitch0.5mm
U703: OPA344_SOT23-5; SOT-23-5

Connections:
/3V3_EXTRA: F701.1; also elsewhere on the board
/GPCLK1: SW701.2 (2A); also elsewhere on the board
/I2C_SCL: SW702.4 (4A); also elsewhere on the board
/I2C_SDA: SW702.3 (3A); also elsewhere on the board
/I2S_BCLK: SW701.3 (3A); also elsewhere on the board
/I2S_LRCLK: SW701.4 (4A); also elsewhere on the board
/I2S_SDIN: SW702.1 (1A); also elsewhere on the board
/I2S_SDOUT: SW702.2 (2A); also elsewhere on the board
/labio-audio/BCLK_J: SW701.6 (3B), U702.5 (BCLK)
/labio-audio/LINPUT1: P703.1, SW701.8 (1B), U702.28 (LINPUT1)
/labio-audio/LINPUT2: P703.3, U702.26 (LINPUT2)
/labio-audio/LRCLK_J: SW701.5 (4B), U702.9 (ADCLRC)
/labio-audio/MCLK_J: SW701.7 (2A), U702.1 (MCLK)
/labio-audio/MEMS_MIC: C704.2, C720.2, U701.4 (SIG)
/labio-audio/MEMS_MIC_C: C704.1, SW701.1 (1A)
/labio-audio/MICBIAS: C717.1, C718.1, R703.1, U702.22 (MICBIAS)
/labio-audio/RINPUT1: P703.2, U702.27 (RINPUT1)
/labio-audio/RINPUT2: P703.4, U702.25 (RINPUT2)
/labio-audio/SCL_J: SW702.5 (4B), U702.32 (SCLK)
/labio-audio/SDA_J: SW702.6 (3B), U702.31 (SDIN)
/labio-audio/SDIN_J: SW702.8 (1B), U702.6 (DACDAT)
/labio-audio/SDOUT_J: SW702.7 (2A), U702.8 (ADCDAT)
/labio-audio/SPEAKER_L: P704.1, U702.16 (LOUT2)
/labio-audio/SPEAKER_R: P704.2, U702.15 (ROUT2)
/labio-audio/TRRS_HPDETECT: J701.5 (TN), U702.23 (RINPUT3/HPDETECT)
/labio-audio/TRRS_L: C714.1, J701.2 (T)
/labio-audio/TRRS_L_C: C714.2, U702.13 (LOUT1)
/labio-audio/TRRS_MIC: C711.1, U702.24 (LINPUT3)
/labio-audio/TRRS_MIC_BIASED: C709.1, C711.2, J701.1 (S), R702.1, R703.2
/labio-audio/TRRS_R: C715.1, J701.3 (R1)
/labio-audio/TRRS_R_C: C715.2, U702.12 (ROUT1)
/labio-audio/VDD3V3_J: C701.2, C702.1, C703.1, C705.1, C706.1, C707.1, C708.1, C721.2, D701.2 (A), F701.2, P702.1, P702.2, P702.3, P702.4, R704.1, U701.1 (VDD), U702.2 (DCVDD), U702.3 (DBVDD), U702.17 (HPVDD), U702.18 (AVDD), U703.5
GND: C701.1, C702.2, C703.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C712.2, C713.2, C716.2, C717.2, C718.2, C719.1, C721.1, J701.4 (R2), P701.1, P701.2, P701.3, P701.4, R701.1, R702.2, R705.2, U701.2 (GND), U701.3 (GND), U702.4 (DGND), U702.14 (HPGND), U702.19 (AGND), U702.29 (MODE), U702.30 (CSB), U702.33 (PAD), U703.2; also elsewhere on the board
MEMS_MIC_TO_ADC: R707.2, U703.1; also elsewhere on the board
unnamed: C710.1, C712.1, U702.21 (VMID)
unnamed: C713.1, C716.1, U702.20 (VREF)
unnamed: C719.2, R704.2, R705.1, U703.3
unnamed: C720.1, R706.1
unnamed: D701.1 (K), R701.2
unnamed: R706.2, R707.1, U703.4

Notes on the sheet:
Optional 8-ohm speaker with wire leads. Invert ROUT2 to drive as mono.
MEMS Microphone
Extra codec inputs on GSV headers. L/RINPUT1 can be used as DC ADC (no PGA). L/RINPUT1 or L/RINPUT2 can form differential input.
TRRS headset connector for typical smartphone headset.
I2S Audio RPi drives MCLK, SDIN. Codec drives BCLK, LRCLK, SDOUT. Write LRCM=1 to use ADCLRC as LRCLK.
I2C (2 wire) Ctrl 7-bit addr: 0x1A (0011010)
Headset mic bias Suggested by WM8750BL datasheet (pg. 56).
0.25mA max
20mA max (approx from 5W stereo output + mic input)
Mic Amp for ADC

Parts:
C801, C802, C803, C804, C805: dnp; C_0603
SW801, SW802, SW803, SW804, SW805: SW_PUSH; SW_SPST_EVPBF

Connections:
/labio-dpad/DPAD_CENTER: C803.1, SW803.1; also elsewhere on the board
/labio-dpad/DPAD_DOWN: C804.1, SW804.1; also elsewhere on the board
/labio-dpad/DPAD_LEFT: C801.1, SW801.1; also elsewhere on the board
/labio-dpad/DPAD_RIGHT: C805.1, SW805.1; also elsewhere on the board
/labio-dpad/DPAD_UP: C802.1, SW802.1; also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, SW801.2, SW802.2, SW803.2, SW804.2, SW805.2; also elsewhere on the board

Notes on the sheet:
D-Pad Use RPi pull-ups. Optional C for decoupling. Individual IO lines for interrupts.

Schematic: labio-power.sch, Raspberry Pi Embedded Lab I/O

Parts:
P901: CONN_01X06; Pin_Header_Angled_1x06

Connections:
/5V: P901.6; also elsewhere on the board
/labio-dio/VS_MOTOR: P901.1, P901.2; also elsewhere on the board
GND: P901.3, P901.4; also elsewhere on the board

Notes on the sheet:
External Power (Future) Provides logic and motor power from power supply or battery pack with possible charging from USB (rpi) power. 2x motor power for current rating.
